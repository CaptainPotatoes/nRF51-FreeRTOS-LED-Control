# Keil uVision project blinky_FreeRTOS_pca10028.uvprojx, settings and files
target nrf51422_xxac (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51 FREERTOS
  c include: ..\..\config\blinky_FreeRTOS_pca10028;..\..\config;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\toolchain;..\..\..\..\bsp;..\..;..\..\..\..\..\external\freertos\config;..\..\..\..\..\external\freertos\portable\ARM\nrf51;..\..\..\..\..\external\freertos\portable\CMSIS\nrf51;..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\components\drivers_nrf\delay
  asm define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51 FREERTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Documentation
    ../../: Abstract.txt license.txt
  group Third Parties
    ../../../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../../external/freertos/portable/ARM/nrf51/: port.c
    ../../../../../external/freertos/portable/CMSIS/nrf51/: port_cmsis.c port_cmsis_systick.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
